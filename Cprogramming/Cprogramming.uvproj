# Keil uVision project Cprogramming.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2292 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Cprogramming +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s main.c pedina.c pedina.h muro.h muro.c gestioneStampaStringhe.c gestioneStampaStringhe.h gioco.c uart.h gioco.h uart.c coda.c coda.h random.c random.h
  group lib_uCdragon
    ../lib_uCdragon/: board.h config.h def.h LPC2294.h board.c
  group LCD
    ../lib_uCdragon/LCD/: LCD_YM12864I.c LCD_YM12864I.h
  group timer
    ../lib_uCdragon/timers/: timer.c timer.h timer1.c timer1.h
